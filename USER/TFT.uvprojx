# Keil uVision project TFT.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 跑马灯 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SAVE;..\SAVE\24CXX;..\SYSTEM\usart;..\SAVE\oled;..\SAVE\AS608;..\SAVE\USART2;..\SAVE\TIMER;..\SAVE\FLASH;..\SAVE\LCD;..\SAVE\SPI;..\SAVE\key;..\SAVE\RCC522;..\SAVE\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SAVE
    ../SAVE/: led.c IIC.c door.c
    ../SAVE/24CXX/: 24cxx.c
    ../SAVE/oled/: oled.c
    ../SAVE/AS608/: as608.c
    ../SAVE/USART2/: usart2.c
    ../SAVE/TIMER/: timer.c
    ../SAVE/SPI/: spi.c
    ../SAVE/LCD/: lcd.c
    ../SAVE/key/: key.c
    ../SAVE/RCC522/: RC522.c RFID_API.c
    ../SAVE/MALLOC/: malloc.c
